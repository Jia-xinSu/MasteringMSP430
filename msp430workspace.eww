<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EmptyProject\EmptyProject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\UCS\practice1\practice1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\GPIO\practice2\practice2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\GPIO\practice3\practice3.ewp</path>
    </project>
    <batchBuild />
</workspace>
